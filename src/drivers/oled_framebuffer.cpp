#include "drivers/oled_framebuffer.h"

#include <cstring>

namespace drivers::fb {

const uint8_t kFont5x7[] = {
    0x00,0x00,0x00,0x00,0x00, 0x00,0x00,0x5F,0x00,0x00, 0x00,0x07,0x00,0x07,0x00, 0x14,0x7F,0x14,0x7F,0x14,
    0x24,0x2A,0x7F,0x2A,0x12, 0x23,0x13,0x08,0x64,0x62, 0x36,0x49,0x55,0x22,0x50, 0x00,0x05,0x03,0x00,0x00,
    0x00,0x1C,0x22,0x41,0x00, 0x00,0x41,0x22,0x1C,0x00, 0x14,0x08,0x3E,0x08,0x14, 0x08,0x08,0x3E,0x08,0x08,
    0x00,0x50,0x30,0x00,0x00, 0x08,0x08,0x08,0x08,0x08, 0x00,0x60,0x60,0x00,0x00, 0x20,0x10,0x08,0x04,0x02,
    0x3E,0x51,0x49,0x45,0x3E, 0x00,0x42,0x7F,0x40,0x00, 0x42,0x61,0x51,0x49,0x46, 0x21,0x41,0x45,0x4B,0x31,
    0x18,0x14,0x12,0x7F,0x10, 0x27,0x45,0x45,0x45,0x39, 0x3C,0x4A,0x49,0x49,0x30, 0x01,0x71,0x09,0x05,0x03,
    0x36,0x49,0x49,0x49,0x36, 0x06,0x49,0x49,0x29,0x1E, 0x00,0x36,0x36,0x00,0x00, 0x00,0x56,0x36,0x00,0x00,
    0x08,0x14,0x22,0x41,0x00, 0x14,0x14,0x14,0x14,0x14, 0x00,0x41,0x22,0x14,0x08, 0x02,0x01,0x51,0x09,0x06,
    0x32,0x49,0x79,0x41,0x3E, 0x7E,0x11,0x11,0x11,0x7E, 0x7F,0x49,0x49,0x49,0x36, 0x3E,0x41,0x41,0x41,0x22,
    0x7F,0x41,0x41,0x22,0x1C, 0x7F,0x49,0x49,0x49,0x41, 0x7F,0x09,0x09,0x09,0x01, 0x3E,0x41,0x49,0x49,0x7A,
    0x7F,0x08,0x08,0x08,0x7F, 0x00,0x41,0x7F,0x41,0x00, 0x20,0x40,0x41,0x3F,0x01, 0x7F,0x08,0x14,0x22,0x41,
    0x7F,0x40,0x40,0x40,0x40, 0x7F,0x02,0x04,0x02,0x7F, 0x7F,0x04,0x08,0x10,0x7F, 0x3E,0x41,0x41,0x41,0x3E,
    0x7F,0x09,0x09,0x09,0x06, 0x3E,0x41,0x51,0x21,0x5E, 0x7F,0x09,0x19,0x29,0x46, 0x46,0x49,0x49,0x49,0x31,
    0x01,0x01,0x7F,0x01,0x01, 0x3F,0x40,0x40,0x40,0x3F, 0x1F,0x20,0x40,0x20,0x1F, 0x3F,0x40,0x38,0x40,0x3F,
    0x63,0x14,0x08,0x14,0x63, 0x07,0x08,0x70,0x08,0x07, 0x61,0x51,0x49,0x45,0x43, 0x00,0x7F,0x41,0x41,0x00,
    0x02,0x04,0x08,0x10,0x20, 0x00,0x41,0x41,0x7F,0x00, 0x04,0x02,0x01,0x02,0x04, 0x40,0x40,0x40,0x40,0x40,
    0x00,0x01,0x02,0x04,0x00, 0x20,0x54,0x54,0x54,0x78, 0x7F,0x48,0x44,0x44,0x38, 0x38,0x44,0x44,0x44,0x20,
    0x38,0x44,0x44,0x48,0x7F, 0x38,0x54,0x54,0x54,0x18, 0x08,0x7E,0x09,0x01,0x02, 0x0C,0x52,0x52,0x52,0x3E,
    0x7F,0x08,0x04,0x04,0x78, 0x00,0x44,0x7D,0x40,0x00, 0x20,0x40,0x44,0x3D,0x00, 0x7F,0x10,0x28,0x44,0x00,
    0x00,0x41,0x7F,0x40,0x00, 0x7C,0x04,0x18,0x04,0x78, 0x7C,0x08,0x04,0x04,0x78, 0x38,0x44,0x44,0x44,0x38,
    0x7C,0x14,0x14,0x14,0x08, 0x08,0x14,0x14,0x18,0x7C, 0x7C,0x08,0x04,0x04,0x08, 0x48,0x54,0x54,0x54,0x20,
    0x04,0x3F,0x44,0x40,0x20, 0x3C,0x40,0x40,0x20,0x7C, 0x1C,0x20,0x40,0x20,0x1C, 0x3C,0x40,0x30,0x40,0x3C,
    0x44,0x28,0x10,0x28,0x44, 0x0C,0x50,0x50,0x50,0x3C, 0x44,0x64,0x54,0x4C,0x44, 0x00,0x08,0x36,0x41,0x00,
    0x00,0x00,0x7F,0x00,0x00, 0x00,0x41,0x36,0x08,0x00, 0x10,0x08,0x08,0x10,0x08,
    // Diagonal-arrow glyphs (kGlyphArrowNE/NW/SE/SW, index 0x7F-0x82), used
    // for the PARAM family's diagonal axis labels.
    // NE/SW are 180-degree rotations of each other; NW/SE are the mirror of
    // NE/SW across the vertical axis — kept that way so the two ends of
    // each diagonal axis read as a matched pair on the OLED.
    0x40,0x20,0x08,0x05,0x03,  // NE: tail bottom-left, head top-right
    0x03,0x05,0x08,0x20,0x40,  // NW: tail bottom-right, head top-left
    0x01,0x02,0x08,0x50,0x60,  // SE: tail top-left, head bottom-right
    0x60,0x50,0x08,0x02,0x01,  // SW: tail top-right, head bottom-left
};

static inline uint8_t clamp_u8(uint8_t v, uint8_t max) { return v > max ? max : v; }

void clear(uint8_t* buf, size_t size) { std::memset(buf, 0, size); }

void draw_text(uint8_t* buf, uint8_t width, uint8_t height, uint8_t x,
               uint8_t page, const char* text, bool invert) {
  if (!text) return;
  if (page >= (height / 8)) return;
  x = clamp_u8(x, width - 1);

  const uint8_t mask = invert ? 0xFF : 0x00;
  size_t col = x;
  while (*text && col + 6 <= width) {
    // Read as unsigned: codepoints above 0x7F (the diagonal-arrow glyphs)
    // would sign-extend to negative ints through a plain (signed) char and
    // wrongly fail the kFontFirstChar bound below.
    int c = static_cast<unsigned char>(*text++);
    if (c < kFontFirstChar || c > kFontLastChar) c = '?';
    const uint8_t* glyph = &kFont5x7[(c - kFontFirstChar) * 5];
    size_t base = (page * width) + col;
    for (int i = 0; i < 5; ++i) {
      buf[base + i] = glyph[i] ^ mask;
    }
    buf[base + 5] = mask;  // 1px space (inverted = filled)
    col += 6;
  }
}

void draw_text_2x(uint8_t* buf, uint8_t width, uint8_t height, uint8_t x,
                  uint8_t page, const char* text, bool invert) {
  if (!text) return;
  if (page + 1 >= (height / 8)) return;  // needs 2 pages
  x = clamp_u8(x, width - 1);

  const uint8_t mask = invert ? 0xFF : 0x00;
  size_t col = x;
  while (*text && col + 12 <= width) {
    // See draw_text() above: unsigned read avoids sign-extending the
    // glyphs above 0x7F into a false kFontFirstChar failure.
    int c = static_cast<unsigned char>(*text++);
    if (c < kFontFirstChar || c > kFontLastChar) c = '?';
    const uint8_t* glyph = &kFont5x7[(c - kFontFirstChar) * 5];

    for (int i = 0; i < 5; ++i) {
      // Double each bit vertically: 7-bit column → 14-bit column
      uint16_t doubled = 0;
      uint8_t b = glyph[i];
      for (int bit = 0; bit < 7; ++bit) {
        if (b & (1 << bit)) {
          doubled |= (uint16_t(3) << (bit * 2));
        }
      }

      uint8_t lo = static_cast<uint8_t>(doubled & 0xFF) ^ mask;
      uint8_t hi = static_cast<uint8_t>((doubled >> 8) & 0xFF) ^ mask;

      // Write 2 columns (horizontal doubling)
      size_t base0 = (page * width) + col;
      size_t base1 = ((page + 1) * width) + col;
      buf[base0]     = lo;
      buf[base0 + 1] = lo;
      buf[base1]     = hi;
      buf[base1 + 1] = hi;
      col += 2;
    }
    // 2px space
    size_t base0 = (page * width) + col;
    size_t base1 = ((page + 1) * width) + col;
    buf[base0]     = mask;
    buf[base0 + 1] = mask;
    buf[base1]     = mask;
    buf[base1 + 1] = mask;
    col += 2;
  }
}

void draw_hline(uint8_t* buf, uint8_t width, uint8_t height, uint8_t x0,
                uint8_t x1, uint8_t y) {
  if (y >= height) return;
  if (x0 >= width) return;
  if (x0 > x1) {
    const uint8_t tmp = x0;
    x0 = x1;
    x1 = tmp;
  }
  uint8_t page = y / 8;
  uint8_t bit = 1 << (y % 8);
  if (x1 >= width) x1 = width - 1;
  for (uint8_t col = x0; col <= x1; ++col) {
    buf[page * width + col] |= bit;
  }
}

void draw_vline(uint8_t* buf, uint8_t width, uint8_t height, uint8_t x,
                uint8_t y0, uint8_t y1) {
  if (x >= width || y0 >= height) return;
  if (y0 > y1) {
    const uint8_t tmp = y0;
    y0 = y1;
    y1 = tmp;
  }
  if (y1 >= height) y1 = height - 1;
  for (uint8_t y = y0; y <= y1; ++y) {
    const uint8_t page = y / 8;
    const uint8_t bit = 1u << (y % 8);
    buf[page * width + x] |= bit;
  }
}

void fill_rect(uint8_t* buf, uint8_t width, uint8_t height, uint8_t x,
              uint8_t y, uint8_t w, uint8_t h, bool on) {
  if (w == 0 || h == 0 || x >= width || y >= height) return;

  uint16_t x1 = static_cast<uint16_t>(x) + static_cast<uint16_t>(w) - 1u;
  uint16_t y1 = static_cast<uint16_t>(y) + static_cast<uint16_t>(h) - 1u;
  if (x1 >= width) x1 = width - 1;
  if (y1 >= height) y1 = height - 1;

  for (uint8_t yy = y; yy <= y1; ++yy) {
    const uint8_t page = yy / 8;
    const uint8_t bit = 1u << (yy % 8);
    for (uint8_t xx = x; xx <= x1; ++xx) {
      uint8_t& dst = buf[page * width + xx];
      if (on) {
        dst |= bit;
      } else {
        dst &= static_cast<uint8_t>(~bit);
      }
    }
  }
}

void fill_line(uint8_t* buf, uint8_t width, uint8_t height, uint8_t page,
              uint8_t value) {
  if (page >= height / 8) return;
  std::memset(&buf[page * width], value, width);
}

}  // namespace drivers::fb
